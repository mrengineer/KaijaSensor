# Keil uVision project FW.uvprojx, settings and files
target FW (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L151RD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FW
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xD
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l151xd.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_gpio.c stm32l1xx_hal_cortex.c stm32l1xx_hal.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_uart.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_adc.c stm32l1xx_hal_rcc.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_flash.c stm32l1xx_ll_sdmmc.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_pwr.c stm32l1xx_hal_sd.c stm32l1xx_hal_flash_ramfunc.c
  group Application/User
    ../Src/: stm32l1xx_it.c bsp_driver_sd.c stm32l1xx_hal_msp.c main.c fatfs.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
software components: CMSIS:CORE 4.1.0
